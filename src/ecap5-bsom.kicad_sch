File: src/ecap5-bsom.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: 🔄 Replace the eMMC IC (#34)
